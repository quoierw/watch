# Keil uVision project watch.uvprojx, settings and files
target watch (5060750::V5.06 update 6 (build 750)::..\..\..\Program Files\Keil_v5\ARM\ARMCC)
  device: STM32F411CEUx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.3.1.1
  cpu: IRAM(0x20000000-0x2001FFFF) IROM(0x8000000-0x807FFFF)  CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4") TZ
  output: watch +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32F411xE
  c include: ../Core/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../Drivers/CMSIS/Include;../Middlewares/Third_Party/FreeRTOS/Source/include;../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2;../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F
  asm include: ../Drivers/CMSIS/Include
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group Application/MDK-ARM
    ./: startup_stm32f411xe.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c freertos.c dma.c spi.c tim.c stm32f4xx_it.c stm32f4xx_hal_msp.c stm32f4xx_hal_timebase_tim.c
  group Application/User/System
    ../SYSTEM/: delay.c
  group Application/User/Tasks
    ../User/Tasks/Src/: user_TaskInit.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f4xx.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_exti.c stm32f4xx_hal_spi.c
  group Drives/User/BSP
    ../BSP/LCD/: lcd.c lcd_init.c
    ../BSP/TOUCH/: CST816.c
    ../BSP/IIC/: iic_hal.c
    ../BSP/AHT21/: AHT21.c
  group Middlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2/: cmsis_os2.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F/: port.c
  group LVGL/lvgl/src/porting
    ../LVGL/lvgl/src/porting/: lv_port_disp.c lv_port_indev.c
  group LVGL/lvgl/src/font
    ../LVGL/lvgl/src/font/: lv_font.c lv_font_dejavu_16_persian_hebrew.c lv_font_fmt_txt.c lv_font_loader.c lv_font_montserrat_8.c lv_font_montserrat_10.c lv_font_montserrat_12.c lv_font_montserrat_12_subpx.c lv_font_montserrat_14.c lv_font_montserrat_16.c lv_font_montserrat_18.c lv_font_montserrat_20.c lv_font_montserrat_22.c lv_font_montserrat_24.c lv_font_montserrat_26.c lv_font_montserrat_28.c lv_font_montserrat_28_compressed.c lv_font_montserrat_30.c lv_font_montserrat_32.c lv_font_montserrat_34.c lv_font_montserrat_36.c lv_font_montserrat_38.c lv_font_montserrat_40.c lv_font_montserrat_42.c lv_font_montserrat_44.c lv_font_montserrat_46.c lv_font_montserrat_48.c lv_font_simsun_16_cjk.c lv_font_unscii_8.c lv_font_unscii_16.c
  group LVGL/lvgl/src/gpu
    ../LVGL/lvgl/src/draw/sdl/: lv_draw_sdl.c lv_draw_sdl_arc.c lv_draw_sdl_bg.c lv_draw_sdl_composite.c lv_draw_sdl_img.c lv_draw_sdl_label.c lv_draw_sdl_line.c lv_draw_sdl_mask.c lv_draw_sdl_polygon.c lv_draw_sdl_rect.c lv_draw_sdl_stack_blur.c lv_draw_sdl_texture_cache.c lv_draw_sdl_utils.c
    ../LVGL/lvgl/src/draw/stm32_dma2d/: lv_gpu_stm32_dma2d.c
  group LVGL/lvgl/src/hal
    ../LVGL/lvgl/src/hal/: lv_hal_disp.c lv_hal_indev.c lv_hal_tick.c
  group LVGL/lvgl/src/misc
    ../LVGL/lvgl/src/misc/: lv_anim.c lv_anim_timeline.c lv_area.c lv_async.c lv_bidi.c lv_color.c lv_fs.c lv_gc.c lv_ll.c lv_log.c lv_lru.c lv_math.c lv_mem.c lv_printf.c lv_style.c lv_style_gen.c lv_templ.c lv_timer.c lv_tlsf.c lv_txt.c lv_txt_ap.c lv_utils.c
  group LVGL/lvgl/src/widgets
    ../LVGL/lvgl/src/widgets/: lv_arc.c lv_bar.c lv_btn.c lv_btnmatrix.c lv_canvas.c lv_checkbox.c lv_dropdown.c lv_img.c lv_label.c lv_line.c lv_objx_templ.c lv_roller.c lv_slider.c lv_switch.c lv_table.c lv_textarea.c
  group LVGL/lvgl/src/core
    ../LVGL/lvgl/src/core/: lv_disp.c lv_event.c lv_group.c lv_indev.c lv_indev_scroll.c lv_obj.c lv_obj_class.c lv_obj_draw.c lv_obj_pos.c lv_obj_scroll.c lv_obj_style.c lv_obj_style_gen.c lv_obj_tree.c lv_refr.c lv_theme.c
  group LVGL/lvgl/src/draw
    ../LVGL/lvgl/src/draw/: lv_draw.c lv_draw_arc.c lv_draw_img.c lv_draw_label.c lv_draw_line.c lv_draw_mask.c lv_draw_rect.c lv_draw_triangle.c lv_img_buf.c lv_img_cache.c lv_img_decoder.c
    ../LVGL/lvgl/src/draw/sw/: lv_draw_sw.c lv_draw_sw_arc.c lv_draw_sw_blend.c lv_draw_sw_dither.c lv_draw_sw_gradient.c lv_draw_sw_img.c lv_draw_sw_letter.c lv_draw_sw_line.c lv_draw_sw_polygon.c lv_draw_sw_rect.c
  group LVGL/lvgl/src/extra
    ../LVGL/lvgl/src/extra/: lv_extra.c
    ../LVGL/lvgl/src/extra/widgets/animimg/: lv_animimg.c
    ../LVGL/lvgl/src/extra/widgets/calendar/: lv_calendar.c lv_calendar_header_arrow.c lv_calendar_header_dropdown.c
    ../LVGL/lvgl/src/extra/widgets/chart/: lv_chart.c
    ../LVGL/lvgl/src/extra/widgets/colorwheel/: lv_colorwheel.c
    ../LVGL/lvgl/src/extra/widgets/imgbtn/: lv_imgbtn.c
    ../LVGL/lvgl/src/extra/widgets/keyboard/: lv_keyboard.c
    ../LVGL/lvgl/src/extra/widgets/led/: lv_led.c
    ../LVGL/lvgl/src/extra/widgets/list/: lv_list.c
    ../LVGL/lvgl/src/extra/widgets/menu/: lv_menu.c
    ../LVGL/lvgl/src/extra/widgets/meter/: lv_meter.c
    ../LVGL/lvgl/src/extra/widgets/msgbox/: lv_msgbox.c
    ../LVGL/lvgl/src/extra/widgets/span/: lv_span.c
    ../LVGL/lvgl/src/extra/widgets/spinbox/: lv_spinbox.c
    ../LVGL/lvgl/src/extra/widgets/spinner/: lv_spinner.c
    ../LVGL/lvgl/src/extra/widgets/tabview/: lv_tabview.c
    ../LVGL/lvgl/src/extra/widgets/tileview/: lv_tileview.c
    ../LVGL/lvgl/src/extra/widgets/win/: lv_win.c
    ../LVGL/lvgl/src/extra/themes/basic/: lv_theme_basic.c
    ../LVGL/lvgl/src/extra/themes/default/: lv_theme_default.c
    ../LVGL/lvgl/src/extra/themes/mono/: lv_theme_mono.c
    ../LVGL/lvgl/src/extra/others/gridnav/: lv_gridnav.c
    ../LVGL/lvgl/src/extra/others/monkey/: lv_monkey.c
    ../LVGL/lvgl/src/extra/others/snapshot/: lv_snapshot.c
    ../LVGL/lvgl/src/extra/libs/bmp/: lv_bmp.c
    ../LVGL/lvgl/src/extra/libs/ffmpeg/: lv_ffmpeg.c
    ../LVGL/lvgl/src/extra/libs/freetype/: lv_freetype.c
    ../LVGL/lvgl/src/extra/libs/fsdrv/: lv_fs_fatfs.c lv_fs_posix.c lv_fs_stdio.c lv_fs_win32.c
    ../LVGL/lvgl/src/extra/libs/gif/: gifdec.c lv_gif.c
    ../LVGL/lvgl/src/extra/libs/png/: lodepng.c lv_png.c
    ../LVGL/lvgl/src/extra/libs/qrcode/: lv_qrcode.c qrcodegen.c
    ../LVGL/lvgl/src/extra/libs/rlottie/: lv_rlottie.c
    ../LVGL/lvgl/src/extra/libs/sjpg/: lv_sjpg.c tjpgd.c
    ../LVGL/lvgl/src/extra/layouts/flex/: lv_flex.c
    ../LVGL/lvgl/src/extra/layouts/grid/: lv_grid.c
software components: CMSIS:CORE 4.3.0
